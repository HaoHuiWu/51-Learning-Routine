#include <REGX52.H>\
#include "Delay.h"
#include "MatrixLED.h"
/**
  * @brief  点阵屏扫描显示完整图形
  * @param 	无
  * @retval 无
  */
	
unsigned char code Animation[]={
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0xFF,0x08,0x08,0x08,0xFF,0x00,0x0E,0x15,
0x15,0x15,0x08,0x00,0x7E,0x01,0x02,0x00,
0x7E,0x01,0x02,0x00,0x0E,0x11,0x11,0x0E,
0x00,0x00,0x7D,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};//显示图形数据
void main ()
{		
		unsigned char i,offset=0,cout=0;//offset偏移量
		MatrixLED_Init();
    while(1)
    {	
			for(i=0;i<8;i++)
			{
				MatrixLED_ShowClolum(i,Animation[i+offset]);//逐帧偏移
			}
			cout++;
			if(cout==8)//播放速度（可调，越小越快）
			{
				cout=0;
				offset++;
				if(offset==36)
				{
					offset=0;
				}
			}
    }
}
